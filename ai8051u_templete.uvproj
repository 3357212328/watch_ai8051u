# Keil uVision project ai8051u_templete.uvproj, settings and files
target code (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: ai8051u_templete +hex
  link misc: REMOVEUNUSED
  group user
    ./: main.c sys_clock.c sys_clock.h oled_driver.c oled_driver.h oled.c oled.h oled_fonts.c oled_fonts.h oled_ui_driver.c oled_ui_driver.h oled_ui.c oled_ui.h oled_ui_menudata.c usb_ctrl.c usb_ctrl.h watch_time.c watch_face.c watch_icons.c watch_clock.c watch_dino.c watch_plane.c
  group library
    ./: set_i2c.c set_i2c.h set_io.c set_io.h set_timer.c set_timer.h stc_usb_cdc_32g.LIB MDU32_C251.LIB TFPU_C251.LIB
